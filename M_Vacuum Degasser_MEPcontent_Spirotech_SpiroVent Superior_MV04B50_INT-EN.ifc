Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Vacuum Degasser_MEPcontent_Spirotech_SpiroVent Superior_MV04B50_INT-EN.ifc
Time: 2025-08-05T18:30:56+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcBuildingElementProxy: M_Vacuum Degasser_MEPcontent_Spirotech_SpiroVent Superior_MV04B-R_INT-EN:MV04B50, M_Vacuum Degasser_MEPcontent_Spirotech_SpiroVent Superior_MV04B-R_INT-EN:MV04B50:2085154
In: F00
Type - Material: Color RGB 168-168-168, Color RGB 055-055-055, Color RAL 1003
Type - Other - Category: Mechanical Equipment; Connection Diameter: 19.05 mm; Family Name: M_Vacuum Degasser_MEPcontent_Spirotech_SpiroVent Superior_MV04B-R_INT-EN
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - B: 346 mm; Connection Nominal Diameter: 19.05 mm; Connection Outer Diameter: 26.9 mm; D: 334 mm; H: 930 mm; Use Nominal Diameter: yes
Type - Electrical Engineering - Voltage: 230 V
Type - Electrical - Loads - Apparent Load: 500 W
Type - Identity Data - Article Description: Vacuum degasser S400 - 1-4 bar - Breaktank; Article Type: MV04B50; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Vacuum degasser S400 - 1-4 bar - Breaktank; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 12.05; GLN: 8717811000007; GTIN: 8717811048870; Manufacturer: Spirotech; Manufacturer Art. No.: MV04B50; Manufacturer URL: https://www.spirotech.com/8717811048870; MEPcontent Class: VACUUM_DEGASSER; Model: MV04B50; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: MV04B50; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 055-055-055; Grey: Color RGB 168-168-168; Yellow: Color RAL 1003
Type - Mechanical - Maximum Glycol (%): 40; Maximum Installation Volume: 0.1 m3; Temperature Range (°C): 0 - 90; Weight: 35 kg
Type - Mechanical - Loads - Workload: 400000 Pa
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_BuildingElementProxyCommon - Reference: MV04B50; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: MV04B50
Other - Family: M_Vacuum Degasser_MEPcontent_Spirotech_SpiroVent Superior_MV04B-R_INT-EN; Family and Type: M_Vacuum Degasser_MEPcontent_Spirotech_SpiroVent Superior_MV04B-R_INT-EN: MV04B50; Left Clearance Safe: 600 mm; Right Clearance Safe: 600 mm; Top Clearance Safe: 600 mm; Type: MV04B50; Type Id: 2085137
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 4.1487 m2; Volume: 0.0908601 m3
Identity Data - Mark: 4
Mechanical - System Classification: Undefined,Sanitary,Power,Undefined
Mechanical - Flow - Drain Fixture Units: 0; Flow In: 0 m3/s; Flow Out: 0 m3/s; Flow Refill: 0 m3/s
Phasing - Phase Created: 3. New Construction
Visibility - Left Clearance: 600 mm; Right Clearance: 600 mm; Service Space: no; Top Clearance: 600 mm

# IfcDistributionPort (5)
Description: Flow
Name | FlowDirection | PredefinedType
OutPort_2085154_1 | SOURCE | PIPE
InPort_2085154_2 | SINK | PIPE
OutPort_2085154_3 | SOURCE | PIPE | SystemType: SEWAGE
Port_2085154_4 | SOURCEANDSINK | CABLE | SystemType: ELECTRICAL
InPort_2085154_5 | SINK | PIPE
